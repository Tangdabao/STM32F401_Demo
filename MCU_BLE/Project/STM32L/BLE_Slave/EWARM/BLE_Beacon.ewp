# IAR project BLE_Beacon.ewp, settings and files
configuration Release_SPI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; STM32F4XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; DEBUG=1; ENABLE_USART=1; BLUENRG1_NWK_COPROC; SPI_INTERFACE
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Nucleo\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Bluenrg1\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\STM32L1xx_HAL_BlueNRG1_Drivers\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI; ..\..\..\..\Library\STM32L\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Library\STM32L\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Beacon.hex
  ILINK.IlinkOutputFile: BLE_Beacon.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_UART (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; DEBUG=1; ENABLE_USART=1; BLUENRG1_NWK_COPROC; UART_INTERFACE
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Library\STM32L\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Nucleo\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Bluenrg1\inc; ..\..\..\..\Library\STM32L\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\STM32L1xx_HAL_BlueNRG1_Drivers\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI
  ILINK.IlinkIcfFile: stm32l1xx_flash_nucleo.icf
configuration Release_LowPower_UART (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; SYSCLK_MSI=1; ENABLE_MICRO_SLEEP=1; BLUENRG1_NWK_COPROC; UART_INTERFACE
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BLE_Beacon_LowPower.hex
  ILINK.IlinkOutputFile: BLE_Beacon_LowPower.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_nucleo.icf
configuration Release_LowPower_SPI (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; SYSCLK_MSI=1; ENABLE_MICRO_SLEEP=1; BLUENRG1_NWK_COPROC; SPI_INTERFACE
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BLE_Beacon_LowPower.hex
  ILINK.IlinkOutputFile: BLE_Beacon_LowPower.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_nucleo.icf
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../src/: BLE_Beacon_main.c bluenrg_interface.c cube_hal_l1.c hci_parser.c stm32xx_it.c user_timer.c
  group Drivers/BSP/STM32L1xx_BlueNRG1
    ../../../../Library/STM32L/Drivers/BSP/STM32L1xx_BlueNRG1/src/: SDK_EVAL_GPIO.c SDK_EVAL_Spi.c SDK_EVAL_Uart.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../Library/STM32L/Drivers/BSP/STM32L1xx_Nucleo/src/: SDK_Eval_Com.c SDK_Eval_Led.c
  group Drivers/CMSIS
    ../src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Library/STM32L/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares/STM32_BlueNRG1/HAL
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c low_power.c osal.c
  group Middlewares/STM32_BlueNRG1/HAL_Drivers
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/STM32L1xx_HAL_BlueNRG1_Drivers/src/: stm32l1xx_hal_bluenrg1_spi.c
  group Middlewares/STM32_BlueNRG1/HCI
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_events.c bluenrg1_hci_le.c hci.c
  group Middlewares/STM32_BlueNRG1/HCI/Controller
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
